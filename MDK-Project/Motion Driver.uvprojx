# Keil uVision project Motion Driver.uvprojx, settings and files
target MotionDrive (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Motion Driver +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Drivers\CORE;..\Drivers\Libraries\inc;..\Drivers\startup;..\Drivers\USER;..\UCOS\APP;..\UCOS\BSP;..\UCOS\uC-CPU;..\UCOS\uC-CPU\ARM-Cortex-M3\RealView;..\UCOS\uC-LIB;..\UCOS\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOS\uCOS-III;..\UCOS\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\UCOS\uCOS-III\Source;..\hardware
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../Drivers/USER/: stm32f10x_it.c system_stm32f10x.c main.c
  group hardware
    ../hardware/: led.c systemclock.c usart.c
  group CORE
    ../Drivers/CORE/: core_cm3.c
  group Startup
    ../Drivers/startup/: startup_stm32f10x_hd.s
  group Libraries
    ../Drivers/Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UCOS-BSP
    ../UCOS/BSP/: bsp.c
  group UCOS-APP
    ../UCOS/APP/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOS-LIB
    ../UCOS/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOS/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOS-CORE
    ../UCOS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS-PORT
    ../UCOS/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.s os_cpu_c.c
  group UCOS-CPU
    ../UCOS/uC-CPU/: cpu_core.c
    ../UCOS/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
